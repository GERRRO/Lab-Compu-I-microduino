# Repository GERRRO/Lab-Compu-I-microduino

## KiCad design UccMicroDuino/UccMicroDuino.kicad_pcb

Parts:
C1: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: PMLL4148L; D_MELF_Handsoldering
D2, D3: 3.6V 1/2mW; D_SOD-123
D4: Led Green; led
D5: Led Red; led
J1: USB_PCB_A; USB_A_UCC
J2: Header; PinSocket_1x10_P2.54mm_Vertical
R1: 1.5kΩ 5% 1/8W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3: 68Ω 5% 1/8W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5: 330Ω 5% 1/8WR; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: ATtiny85-20S; SOIC-8W_5.3x5.3mm_P1.27mm

Connections:
+5V: C1.1, D1.1 (K), D5.2 (A), J2.1, R1.1, U1.8 (VCC)
GND: C1.2, D2.2 (A), D3.2 (A), J1.4 (GND), J2.2, R4.2, R5.1, U1.4 (GND)
unnamed: D1.2 (A), J1.1 (VBUS)
unnamed: D2.1 (K), J1.2 (D-), R1.2, R2.1
unnamed: D3.1 (K), J1.3 (D+), R3.1
unnamed: D4.2 (A), J2.5, U1.6 (PB1)
unnamed: D4.1 (K), R4.1
unnamed: D5.1 (K), R5.2
unnamed: J2.4, U1.5 (AREF/PB0)
unnamed: J2.6, U1.7 (PB2)
unnamed: J2.7, R2.2, U1.2 (XTAL1/PB3)
unnamed: J2.8, R3.2, U1.3 (XTAL2/PB4)
unnamed: J2.9, U1.1 (~RESET/PB5)

Notes on the sheet:
Main Circuit

Board: 2 copper layers, 43.9 x 38.3 mm, 14 parts (0 on the bottom side), 13 nets.

## Commit log

2024-05-08 Editor de placas modificado correctamente
